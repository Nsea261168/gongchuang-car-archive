# Keil uVision project CtrBoard-H7_FDCAN.uvprojx, settings and files
target CtrBoard-H7_FDCAN (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrBoard-H7_FDCAN +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP/CAN;../BSP/UART;../Drivers/Motor;../Drivers/IMU;../Drivers/IMU/inc;../Drivers/Storage;../Drivers/Actuator;../Drivers/Display;../Drivers/Input;../Drivers/Lidar;../Drivers/LED;../Library/Algorithm;../Library/Control/Pid;../App/System;../App/Tasks;../App/Services;../App/Comm
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fdcan.c spi.c usart.c adc.c dma.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Application/Comm
    ../App/Comm/: chassis_uart3.c
  group Application/Tests
    ../App/Tests/: chassis_escape_test.c
  group Application/Services & Tasks
    ../App/Tasks/: task_manager.c task0.c task1.c task2.c task3.c task4.c task5.c task6.c
    ../App/Services/: input_service.c chassis_motion.c
  group Platform/BSP & Drivers
    ../BSP/CAN/: bsp_fdcan.c
    ../Drivers/Motor/: QD4310.c songjia_motor.c
    ../BSP/UART/: bsp_uart1.c
    ../App/System/: app_scheduler.c app_runtime.c boot_ui.c task_ui.c
    ../Drivers/LED/: ws2812.c
    ../Drivers/IMU/: bmi088_attitude.c bmi088_board.c BMI088driver.c BMI088Middleware.c bmi088_accel.c
    ../Library/Algorithm/: MahonyAHRS.c rate_pi.c
    ../Drivers/Storage/: zero_store.c
    ../Drivers/Actuator/: servo_pwm.c
    ../Drivers/Input/: adc_modlue.c key_bsp.c key_driver.c
    ../Drivers/Display/: lcd.c
    ../Drivers/Lidar/: ld06.c
    ../Library/Control/Pid/: pid.c
software components: CMSIS:CORE 4.3.0
